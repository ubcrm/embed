# Keil uVision project embed-infantry.uvprojx, settings and files
target embed-infantry (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: embed-infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\User;..\User\AHRS;..\User\DSP\Include;..\User\FreeRTOS\include;..\User\FreeRTOS\portable;..\User\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\user_lib;..\User\hardware\ADC;..\User\hardware\BUZZER;..\User\hardware\delay;..\User\hardware\EXIT_Init;..\User\hardware\CAN;..\User\hardware\LED;..\User\hardware\FLASH;..\User\hardware\FRIC;..\User\hardware\LASER;..\User\hardware\POWER_CTRL;..\User\hardware\RC;..\User\hardware\RNG;..\User\hardware\SPI;..\User\hardware\SYS;..\user\hardware\timer;..\User\APP\CAN_Receive;..\User\APP\FreeRTOS_Middleware;..\User\APP\pid;..\User\APP\Remote_Control;..\User\TASK\start_task;..\User\APP\USART_comms;..\User\hardware\usart;..\User\TASK\revolver_task;..\User\TASK\INS_task;..\User\TASK\chassis_task;..\User\TASK\gimbal_task;..\User\TASK\test_task
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f427xx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group freeRTOS
    ../user/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../user/FreeRTOS/portable/MemMang/: heap_4.c
    ../user/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group AHRS
    ../user/AHRS/: AHRS.lib AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c
  group DSP
    ../user/DSP/: arm_cortexM4lf_math.lib
  group user_lib
    ../user/user_lib/: user_lib.c
  group hardware
    ../user/hardware/adc/: adc.c
    ../user/hardware/buzzer/: buzzer.c
    ../user/hardware/can/: can.c
    ../user/hardware/delay/: delay.c
    ../user/hardware/exit_init/: exit_init.c
    ../user/hardware/flash/: flash.c
    ../user/hardware/fric/: fric.c
    ../user/hardware/laser/: laser.c
    ../user/hardware/led/: led.c
    ../user/hardware/power_ctrl/: power_ctrl.c
    ../user/hardware/rc/: rc.c
    ../user/hardware/rng/: rng.c
    ../user/hardware/spi/: spi.c
    ../user/hardware/sys/: sys.c
    ../user/hardware/timer/: timer.c
    ../user/hardware/usart/: usart.c usart.h
  group APP
    ../user/APP/CAN_receive/: CAN_receive.c CAN_receive.h
    ../user/APP/FreeRTOS_middleware/: FreeRTOS_middleware.c FreeRTOS_middleware.h
    ../user/APP/USART_comms/: USART_comms.c USART_comms.h
    ../user/APP/remote_control/: remote_control.c remote_control.h
    ../user/APP/PID/: pid.c pid.h
  group main
    ../user/: main.c main.h
  group TASK
    ../user/TASK/start_task/: start_task.c start_task.h
    ../user/TASK/revolver_task/: revolver_task.c revolver_task.h
    ../user/TASK/INS_task/: INS_task.c INS_task.h
    ../user/TASK/chassis_task/: chassis_task.c chassis_task.h
    ../user/TASK/gimbal_task/: gimbal_task.c gimbal_task.h
    ../user/TASK/test_task/: test_task.c test_task.h
